# IAR project nafe13388_waveform_demo_cm7.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../xip; ../../../../../../CMSIS/Include; ../../../../../../components/lists; ../../../../../../components/uart; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1176/xip; ../../../../../../middleware/freemaster/src/common; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../../middleware/freemaster/src/platforms/gen32le
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: nafe13388_waveform_demo_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1176DVMAA_cm7; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dcdc.c fsl_dcdc.h fsl_flexio.c fsl_flexio.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pmu.c fsl_pmu.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group middleware/freemaster/common
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group middleware/freemaster/driver
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpuart.c freemaster_serial_lpuart.h
  group middleware/freemaster/platform
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group source
    ../: freemaster_cfg.h main.c nafe13388_waveform_demo.c
    ../../../: nafe13388.c nafe13388.h nafe_hal.c nafe_hal.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group xip
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
